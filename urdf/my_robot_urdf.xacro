Commit message: 240623

File: urdf/my_robot_urdf.xacro (robot description, xacro)
@@ -99,5 +99,5 @@
             </geometry>
             <material name="grey" />
-        </visual>
+        </visual>P
         <visual>
             <origin xyz="0.064 0.0463 0.1096" rpy="0 0 0"/>
